# Keil uVision project cash_provide.uvprojx, settings and files
target cash_provide (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cash_provide +hex
  AfterMake: fromelf.exe --bin -o ./obj/cash_provide.bin ./obj/cash_provide.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\include;..\driver_103\inc;..\lib_103\CMSIS\CM3\CoreSupport;..\lib_103\STM32F10x_StdPeriph_Driver\inc;..\lib_103\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\usr_lib_103\inc;..\src_cb\inc;..\app
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../lib_103/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../lib_103/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../lib_103/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group lib
    ../lib_103/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_spi.c stm32f10x_rcc.c stm32f10x_dac.c
  group user_lib
    ../usr_lib_103/src/: baud_adapt_lib.c parallel_to_serial.c pin.c serial_to_parallel.c step_motor_basic.c usart.c dcmotor_lib.c qrcode_scan_lib_hw.c qrcode_scan_lib_nl.c
  group app
    ../app/: main.c stm32f10x_it.c settings.c actions.c console.c console_cmd.c respcode.c parser.c command.c
  group driver
    ../driver_103/src/: autobaud.c digtube.c key.c led.c lowpower.c maincom.c sensor.c switch.c com.c motor.c flash_nvm.c dcmotor.c qrcode_scan.c i2c_EE.c
software components: CMSIS:CORE 5.0.1
